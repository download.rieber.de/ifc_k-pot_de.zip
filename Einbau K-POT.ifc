Properties of the parts of a building model (IFC2X3)

# File
Description: ViewDefinition [CoordinationView]
File name: Projektnummer
Time: 2018-08-06T16:04:07
Written by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013
Made in: 20140606_1530(x64) - Exporter 2015.0.2014.0606 - Default UI
Comment: STEP Physical File produced by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013 * Module: EDMstepFileFactory/EDMstandAlone * Creation date: Mon Aug 06 16:04:07 2018 * Host: C20170719001P * Database: C:\Users\roecko\AppData\Local\Temp\{649889E5-51E8-4C0E-A7DC-F3CF6890DAC3}\ifc * Database version: 5507 * Database creation date: Mon Aug 06 16:04:06 2018 * Schema: IFC2X3 * Model: DataRepository.ifc * Model creation date: Mon Aug 06 16:04:06 2018 * Header model: DataRepository.ifc_HeaderModel * Header model creation date: Mon Aug 06 16:04:06 2018 * EDMuser: sdai-user * EDMgroup: sdai-group * License ID and type: 5605 : Permanent license. Expiry date: * EDMstepFileFactory options: 020000

# IfcProject, Projektnummer
LongName: Projektname; Phase: Projektstatus

# IfcSite, Default
RefLatitude: 52, 30, 59, 759999; RefLongitude: 13, 23, 59, 999999; RefElevation: 0 m
Sonstige - Kategorie: Projektinformationen; Kundenname: Bauherr; Projektadresse: Projektadresse; Projektausgabedatum: Projekt Datum; Projektname: Projektname; Projektnummer: Projektnummer; Projektstatus: Projektstatus; Verfasser eMail: E-Mail; Verfasser Firma 1: Firma 1; Verfasser Firma 2: Firma 2; Verfasser PLZ Ort: PLZ Ort; Verfasser Strasse: Strasse; Verfasser Telefax: Telefax; Verfasser Telefon: Telefon

# IfcBuilding
Pset_BuildingCommon - NumberOfStoreys: 1
Sonstige - Kategorie: Projektinformationen; Kundenname: Bauherr; Projektadresse: Projektadresse; Projektausgabedatum: Projekt Datum; Projektname: Projektname; Projektnummer: Projektnummer; Projektstatus: Projektstatus; Verfasser eMail: E-Mail; Verfasser Firma 1: Firma 1; Verfasser Firma 2: Firma 2; Verfasser PLZ Ort: PLZ Ort; Verfasser Strasse: Strasse; Verfasser Telefax: Telefax; Verfasser Telefon: Telefon

# IfcBuildingStorey, Ebene 0
LongName: Ebene 0; Elevation: 0 m
Sonstige - Kategorie: Ebenen; Familienname: Ebene; Familie: Ebene: Ebene; Familie und Typ: Ebene: Ebene; Typ: Ebene: Ebene; Typ-ID: Ebene: Ebene
ID-Daten - Typname: Ebene; Gebäudegeschoss: yes; Name: Ebene 0; Tragwerk: no
Grafiken - Farbe: 16711680; Linienmuster: Verdeckt; Linienstärke: 1; Symbol: Beschriftung Ebene: Beschriftung Ebene; Symbol bei Ende 1 Standard: no; Symbol bei Ende 2 Standard: yes
Abhängigkeiten - Basishöhe: Projekt-Basispunkt; Ansicht: 0 m
Abmessungen - Höhe für Berechnung: 0 m

# IfcBuildingElementProxy: 84012050_K-POT 1/1-CK-2200 Einbau, QF_Rieber_1 1 CK-2200 Einbau_84012050:84012050_K-POT 1/1-CK-2200 Einbau:377955
In: Ebene 0
Material: Kunststoff, undurchsichtig schwarz, Stahl, Edelstahl, Ceranglas
Pset_BuildingElementProxyCommon - Reference: 84012050_K-POT 1/1-CK-2200 Einbau
Pset_ManufacturerTypeInformation - Manufacturer: Rieber GmbH & Co. KG
Abhängigkeiten - Versatz: 0 m; Ebene: Ebene: Ebene 0; Basisbauteil: Ebene : Ebene 0
Abmessungen - Fläche: 1.26961 m2; Volumen: 0.0116657 m3
Phasen - Phase erstellt: Phase 1
Sichtbarkeit - Freiraum 3D: no
Sonstige - Kategorie: Sonderausstattung; Familie: QF_Rieber_1 1 CK-2200 Einbau_84012050: 84012050_K-POT 1/1-CK-2200 Einbau; Familie und Typ: QF_Rieber_1 1 CK-2200 Einbau_84012050: 84012050_K-POT 1/1-CK-2200 Einbau; Typ: QF_Rieber_1 1 CK-2200 Einbau_84012050: 84012050_K-POT 1/1-CK-2200 Einbau; Typ-ID: QF_Rieber_1 1 CK-2200 Einbau_84012050: 84012050_K-POT 1/1-CK-2200 Einbau; Familienname: QF_Rieber_1 1 CK-2200 Einbau_84012050
Allgemein - CE Kennzeichnung: yes; Ersteller: Rieber GmbH & Co. KG; Höhe: 0.224 m; Länge Gerätebreite: 0.603 m; Tiefe: 0.398 m
Elektro - Phasen: 1; Zuleitung zum Gerät im Lieferumfang: yes; Elektrische leistung: 2200 W; Frequenz: 50 Hz; Maximale Geräteabsicherung: 16 A; Schutzart: IP X0; Spannung: 230 V; Stecker System: kein Stecker
ID-Daten - Gerätegewicht Netto: 8.5; Großküchengerätezuordnung: yes; Menge als Set: no; Zubehör: no; Artikel Nummer: 84012050; Beschreibung: Cerankochfeld mit elektronischer Steuerung. Einbaugerät mit Gehäuse aus Edelstahl; Beschreibung durch Hersteller analog Leistungsverzeichniskurztext: Cerankochfeld mit elektronischer Steuerung. Einbaugerät mit Gehäuse aus Edelstahl; Hersteller: Rieber GmbH & Co. KG; Internetadresse Gerätehersteller: http://www.rieber.de/; Modell: K-POT - 1/1 CK-2200 Einbau; OmniClass-Nummer: 23.40.40.00; Omniclass Nummer und Bezeichnung: 23.40.40.00; OmniClass-Titel: Food Service Equipment and Furnishings; Typname: 84012050_K-POT 1/1-CK-2200 Einbau; URL: http://www.rieber.de/

# IfcBuildingElementProxy: 84012051_K-Pot Einbau 1/1 ch-800, QF_Rieber_1 1 CH-800 Einbau_84012051:84012051_K-Pot Einbau 1/1 ch-800:377939
In: Ebene 0
Material: Kunststoff, undurchsichtig schwarz, Stahl, Edelstahl, Ceranglas
Pset_BuildingElementProxyCommon - Reference: 84012051_K-Pot Einbau 1/1 ch-800
Pset_ManufacturerTypeInformation - Manufacturer: Rieber GmbH & Co. KG
Abhängigkeiten - Basisbauteil: Ebene : Ebene 0; Ebene: Ebene: Ebene 0; Versatz: 0 m
Abmessungen - Fläche: 1.26961 m2; Volumen: 0.0116657 m3
Phasen - Phase erstellt: Phase 1
Sichtbarkeit - Freiraum 3D: no
Sonstige - Familie: QF_Rieber_1 1 CH-800 Einbau_84012051: 84012051_K-Pot Einbau 1/1 ch-800; Familie und Typ: QF_Rieber_1 1 CH-800 Einbau_84012051: 84012051_K-Pot Einbau 1/1 ch-800; Kategorie: Sonderausstattung; Typ: QF_Rieber_1 1 CH-800 Einbau_84012051: 84012051_K-Pot Einbau 1/1 ch-800; Typ-ID: QF_Rieber_1 1 CH-800 Einbau_84012051: 84012051_K-Pot Einbau 1/1 ch-800; Familienname: QF_Rieber_1 1 CH-800 Einbau_84012051
Allgemein - CE Kennzeichnung: yes; Ersteller: Rieber GmbH & Co. KG; Höhe: 0.224 m; Länge Gerätebreite: 0.603 m; Tiefe: 0.398 m
Elektro - Elektrische leistung: 800 W; Frequenz: 50 Hz; Maximale Geräteabsicherung: 16 A; Phasen: 1; Schutzart: IP X0; Spannung: 230 V; Stecker System: kein Stecker; Zuleitung zum Gerät im Lieferumfang: yes
ID-Daten - Artikel Nummer: 84012051; Beschreibung: Ceranwarmhaltefeld mit elektronischer Steuerung. Einbaugerät mit Gehäuse aus Edelstahl; Beschreibung durch Hersteller analog Leistungsverzeichniskurztext: Ceranwarmhaltefeld mit elektronischer Steuerung. Einbaugerät mit Gehäuse aus Edelstahl; Gerätegewicht Netto: 8.5; Großküchengerätezuordnung: yes; Hersteller: Rieber GmbH & Co. KG; Internetadresse Gerätehersteller: http://www.rieber.de/; Menge als Set: no; Modell: K-Pot Einbau 1/1 ch-800; OmniClass-Nummer: 23.40.40.00; Omniclass Nummer und Bezeichnung: 23.40.40.00; OmniClass-Titel: Food Service Equipment and Furnishings; Typname: 84012051_K-Pot Einbau 1/1 ch-800; URL: http://www.rieber.de/; Zubehör: no

# IfcBuildingElementProxy: 84012052_K-POT 1/1-CK-2200 2 Zonen Einbau, QF_Rieber_1 1 CK-2200 2 Zonen Einbau_84012052:84012052_K-POT 1/1-CK-2200 2 Zonen Einbau:377947
In: Ebene 0
Material: Kunststoff, undurchsichtig schwarz, Stahl, Edelstahl, Ceranglas
Pset_BuildingElementProxyCommon - Reference: 84012052_K-POT 1/1-CK-2200 2 Zonen Einbau
Pset_ManufacturerTypeInformation - Manufacturer: Rieber GmbH & Co. KG
Abhängigkeiten - Versatz: 0 m; Basisbauteil: Ebene : Ebene 0; Ebene: Ebene: Ebene 0
Abmessungen - Fläche: 1.27099 m2; Volumen: 0.0116765 m3
Phasen - Phase erstellt: Phase 1
Sichtbarkeit - Freiraum 3D: no
Sonstige - Kategorie: Sonderausstattung; Familie: QF_Rieber_1 1 CK-2200 2 Zonen Einbau_84012052: 84012052_K-POT 1/1-CK-2200 2 Zonen Einbau; Familie und Typ: QF_Rieber_1 1 CK-2200 2 Zonen Einbau_84012052: 84012052_K-POT 1/1-CK-2200 2 Zonen Einbau; Typ: QF_Rieber_1 1 CK-2200 2 Zonen Einbau_84012052: 84012052_K-POT 1/1-CK-2200 2 Zonen Einbau; Typ-ID: QF_Rieber_1 1 CK-2200 2 Zonen Einbau_84012052: 84012052_K-POT 1/1-CK-2200 2 Zonen Einbau; Familienname: QF_Rieber_1 1 CK-2200 2 Zonen Einbau_84012052
Allgemein - CE Kennzeichnung: yes; Ersteller: Rieber GmbH & Co. KG; Höhe: 0.224 m; Länge Gerätebreite: 0.603 m; Tiefe: 0.398 m
Elektro - Phasen: 1; Zuleitung zum Gerät im Lieferumfang: yes; Elektrische leistung: 2200 W; Frequenz: 50 Hz; Maximale Geräteabsicherung: 16 A; Schutzart: IP X0; Spannung: 230 V; Stecker System: kein Stecker
ID-Daten - Gerätegewicht Netto: 8.5; Großküchengerätezuordnung: yes; Menge als Set: no; Zubehör: no; Artikel Nummer: 84012052; Beschreibung: Cerankochfeld, K-POT 2 Zonen mit elektronischer Steuerung, Einbaugerät mit Gehäuse aus Edelstahl Einbaugerät mit Gehäuse aus Edelstahl; Beschreibung durch Hersteller analog Leistungsverzeichniskurztext: Cerankochfeld, K-POT 2 Zonen mit elektronischer Steuerung, Einbaugerät mit Gehäuse aus Edelstahl Einbaugerät mit Gehäuse aus Edelstahl; Hersteller: Rieber GmbH & Co. KG; Internetadresse Gerätehersteller: http://www.rieber.de/; Modell: K-POT - 1/1 CK-2200 2 Zonen Einbau; OmniClass-Nummer: 23.40.40.00; Omniclass Nummer und Bezeichnung: 23.40.40.00; OmniClass-Titel: Food Service Equipment and Furnishings; Typname: 84012052_K-POT 1/1-CK-2200 2 Zonen Einbau; URL: http://www.rieber.de/

# IfcBuildingElementProxy: 84012053_K-POT-1/1 ik-3600Q 2 Zonen Einbau, QF_Rieber_1 1 ik-3600Q 2 Zonen Einbau_84012053:84012053_K-POT-1/1 ik-3600Q 2 Zonen Einbau:377963
In: Ebene 0
Material: Kunststoff, undurchsichtig schwarz, Stahl, Edelstahl, Ceranglas
Sonstige - Kategorie: Sonderausstattung; Familienname: QF_Rieber_1 1 ik-3600Q 2 Zonen Einbau_84012053; Familie: QF_Rieber_1 1 ik-3600Q 2 Zonen Einbau_84012053: 84012053_K-POT-1/1 ik-3600Q 2 Zonen Einbau; Familie und Typ: QF_Rieber_1 1 ik-3600Q 2 Zonen Einbau_84012053: 84012053_K-POT-1/1 ik-3600Q 2 Zonen Einbau; Typ: QF_Rieber_1 1 ik-3600Q 2 Zonen Einbau_84012053: 84012053_K-POT-1/1 ik-3600Q 2 Zonen Einbau; Typ-ID: QF_Rieber_1 1 ik-3600Q 2 Zonen Einbau_84012053: 84012053_K-POT-1/1 ik-3600Q 2 Zonen Einbau
ID-Daten - Gerätegewicht Netto: 8.5; Großküchengerätezuordnung: yes; Menge als Set: no; Zubehör: no; Artikel Nummer: 84012053; Beschreibung: Induktionskochfeld K-POT 2 Zonen. Einbaugerät mit Gehäuse aus Edelstahl; Beschreibung durch Hersteller analog Leistungsverzeichniskurztext: Induktionskochfeld K-POT 2 Zonen. Einbaugerät mit Gehäuse aus Edelstahl; Hersteller: Rieber GmbH & Co. KG; Internetadresse Gerätehersteller: http://www.rieber.de/; Modell: K-POT-1/1 ik-3600Q 2 Zonen Einbau; OmniClass-Nummer: 23.40.40.00; Omniclass Nummer und Bezeichnung: 23.40.40.00; OmniClass-Titel: Food Service Equipment and Furnishings; Typname: 84012053_K-POT-1/1 ik-3600Q 2 Zonen Einbau; URL: http://www.rieber.de/
Elektro - Phasen: 1; Zuleitung zum Gerät im Lieferumfang: yes; Elektrische leistung: 3600 W; Frequenz: 50 Hz; Maximale Geräteabsicherung: 16 A; Schutzart: IP X0; Spannung: 230 V; Stecker System: kein Stecker
Pset_BuildingElementProxyCommon - Reference: 84012053_K-POT-1/1 ik-3600Q 2 Zonen Einbau
Pset_ManufacturerTypeInformation - Manufacturer: Rieber GmbH & Co. KG
Abhängigkeiten - Ebene: Ebene: Ebene 0; Versatz: 0 m; Basisbauteil: Ebene : Ebene 0
Abmessungen - Fläche: 1.3519 m2; Volumen: 0.0142343 m3
Phasen - Phase erstellt: Phase 1
Sichtbarkeit - Freiraum 3D: no
Allgemein - CE Kennzeichnung: yes; Ersteller: Rieber GmbH & Co. KG; Höhe: 0.224 m; Länge Gerätebreite: 0.603 m; Tiefe: 0.398 m
